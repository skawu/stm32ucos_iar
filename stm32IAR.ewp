# IAR project stm32IAR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32F10X_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ; CMSIS\; FWLIB\inc\; user\; Driver\; Driver\led\; uCOS-II\Source\; uCOS-II\Ports\arm-cortex-m3\Generic\IAR\; D:\IAR Systems\Embedded Workbench 7.0\arm\inc\c; common\; Driver\uart\; Driver\esp8266\; Driver\motor\; Driver\mpu6050\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm32IAR.bin
  ILINK.IlinkOutputFile: stm32IAR.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS/startup
    CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS/system
    CMSIS/: system_stm32f10x.c
  group common
    common/: queue.c
  group Driver/esp8266
    Driver/esp8266/: esp8266.c
  group Driver/LED
    Driver/led/: led.c
  group Driver/motor
    Driver/motor/: motor.c
  group Driver/mpu6050
    Driver/mpu6050/: i2c.c mpu6050.c
  group Driver/uart
    Driver/uart/: uart.c
  group FWLIB
    FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group ucosii_ports
    uCOS-II/Ports/arm-cortex-m3/Generic/IAR/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group ucosii_source
    uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group user
    user/: main.c stm32f10x_it.c
